# Keil uVision project Datalogger.uvproj, settings and files
target Datalogger kit (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DATALOGGER +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Library_stm\CMSIS\Include;..\..\Library_stm\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library_stm\STM32F4-Discovery_SDIO;..\..\Library_stm\STM32F4xx_StdPeriph_Driver\inc;..\MDK-ARM;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ../../Library_stm/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c
  group MDK-ARM
    ../: startup_stm32f4xx.s
  group FatFs
    ../: diskio.c ff.c
  group STM32F4_Discovery_SDIO
    ../../Library_stm/STM32F4-Discovery_SDIO/: stm32f4_discovery_sdio_sd.c stm32f4_discovery.c
  group User
    ../User/: main.c system_stm32f4xx.c stm32f4xx_it.c fonctionsUsart.c fonctionsInit.c itData.c fifo.c
